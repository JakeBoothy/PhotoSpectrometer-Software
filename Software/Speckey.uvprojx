# Keil uVision project Speckey.uvprojx, settings and files
target Build (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MK02FN64xxx10 NXP
  pack: Keil.Kinetis_K00_DFP.1.0.0
  cpu: IRAM(0x20000000,0x02000) IRAM2(0x1FFFE000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Speckey
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MK02FN64VLF10
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: .;.\fsl_drivers;.\startup;.\utilities;.\SDK\devices\MK02F12810;.\SDK\devices\MK02F12810\drivers;.\SDK\devices\MK02F12810\utilities;.\SDK\CMSIS\Include
  asm define: DEBUG
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: .\SDK\devices\MK02F12810\arm\MK02FN64xxx10_flash.scf
  link misc: --remove
  group startup
    ./SDK/devices/MK02F12810/arm/: startup_MK02F12810.s
    ./SDK/devices/MK02F12810/: system_MK02F12810.c system_MK02F12810.h
  group fsl_drivers
    ./fsl_drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_ewm.c fsl_ewm.h fsl_flash.c fsl_flash.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
    ./startup/: fsl_device_registers.h
  group utilities
    ./utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ./: pin_mux.c board.c clock_config.c
  group Source
    ./: main.c gpio.c uart.c adc.c timers.c
  group Headers
    ./: pin_mux.h board.h clock_config.h gpio.h uart.h adc.h timers.h
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0
